.title PMOS
.options post

**** include model file ****
.inc  ../par0.18um.net

**** components ****
